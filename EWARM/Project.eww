<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BOI_STM32_476VG.ewp</path>
  </project>
  <batchBuild />
</workspace>
